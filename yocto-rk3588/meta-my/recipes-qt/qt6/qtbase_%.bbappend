FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-HACK-qtbase-build-using-libmali.patch"
